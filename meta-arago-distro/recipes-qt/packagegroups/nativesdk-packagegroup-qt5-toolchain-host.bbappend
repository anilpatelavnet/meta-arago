RDEPENDS_${PN}_remove = "nativesdk-perl-modules"
